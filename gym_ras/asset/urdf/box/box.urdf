Commit message: add dsa rep & add target object & add image noise

File: gym_ras/asset/urdf/box/box.urdf (robot description, URDF)
Before this commit: robot sphere, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.006 0.006 0.006; visual box size=0.006 0.006 0.006
